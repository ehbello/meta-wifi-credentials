PACKAGECONFIG:remove = "networkd resolved"
